SRC_URI += "file://xlnk_driver.cfg"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

